# Keil uVision project DrivePlatform3_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: DrivePlatform3_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h UART.c UART.h UART_PM.c UART_INT.c UART_BOOT.c TIMER.c TIMER.h TIMER_PM.c DEBUG_LED_1_aliases.h DEBUG_LED_1.c DEBUG_LED_1.h Isr_tx.c Isr_tx.h Isr_rx.c Isr_rx.h TIMER_CLOCK.c TIMER_CLOCK.h Isr_timer.c Isr_timer.h StartBitStatus.c StartBitStatus.h DFF_Clock.c DFF_Clock.h DFF_Reset_aliases.h DFF_Reset.c DFF_Reset.h UART_IntClock.c UART_IntClock.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h
target Release (ARM-GNU)
  device: CY8C5568AXI-060 Cypress
  cpu: as above
  output: DrivePlatform3_PSoC5lib (library)
